options:
  parameters:
    author: pi
    generate_options: qt_gui
    id: radioApp
    output_language: python
    title: radioApp
  states: {}

blocks:
- name: centerFreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: 88.3e6
    step: 400e3
    stop: 108.9e6
    value: 94.3e6
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to recordings
      and adds timestamp
    value: rootdir+record_file_path+"_"+"Station1:"+str(int(centerFreq+station1))+"Hz_""Station2:"+str(int(centerFreq+station2))+"Hz_"+str(int(samp_rate))+"sps_"+str(rfGain)+"dB_"
  states: {}
- name: rec_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 4,0,1,1
    initPressed: 'False'
    label: RECORD
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: green
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"/Documents/UBA/proyectoSDR/flowgraphs/recordings/"'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF Gain (dB)
    start: '0'
    step: '0.1'
    stop: '30'
    value: '25'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: station1
  id: variable_qtgui_chooser
  parameters:
    labels: '["La 88.3", "Oldies FM 90.3", "Radio Futura 91.1", "Zoe Gospel 91.5", "Radio Disney 91.9", "Urbana 92.5", "Oceano 93.9", "Emisora del Sur 94.7", "Emisora del Plata 95.5", "Emisora Alfa 96.3", "Babel 97.1", "M24 97.9", "Diamante 98.7", "Emisora del Sol 99.5", "Aire 100.3", "La Voz 101.3", "Azul 101.9", "Latina 103.7", "Radio Cero 104.3", "Galaxia 105.9", "La Ley 106.7", "Uni Radio 107.7"]'
    num_opts: '0'
    options: '[88.3e6, 90.3e6, 91.1e6, 91.5e6, 91.9e6, 92.5e6, 93.9e6, 94.7e6, 95.5e6, 96.3e6, 97.1e6, 97.9e6, 98.7e6, 99.5e6, 100.3e6, 101.3e6, 101.9e6, 103.7e6, 104.3e6, 105.9e6, 106.7e6, 107.7e6]'
    type: real
    value: 88.3e6
  states: {}
- name: station2
  id: variable_qtgui_chooser
  parameters:
    labels: '["La 88.3", "Oldies FM 90.3", "Radio Futura 91.1", "Zoe Gospel 91.5", "Radio Disney 91.9", "Urbana 92.5", "Oceano 93.9", "Emisora del Sur 94.7", "Emisora del Plata 95.5", "Emisora Alfa 96.3", "Babel 97.1", "M24 97.9", "Diamante 98.7", "Emisora del Sol 99.5", "Aire 100.3", "La Voz 101.3", "Azul 101.9", "Latina 103.7", "Radio Cero 104.3", "Galaxia 105.9", "La Ley 106.7", "Uni Radio 107.7"]'
    num_opts: '0'
    options: '[88.3e6, 90.3e6, 91.1e6, 91.5e6, 91.9e6, 92.5e6, 93.9e6, 94.7e6, 95.5e6, 96.3e6, 97.1e6, 97.9e6, 98.7e6, 99.5e6, 100.3e6, 101.3e6, 101.9e6, 103.7e6, 104.3e6, 105.9e6, 106.7e6, 107.7e6]'
    type: real
    value: 88.3e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 200e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".wav" if rec_button == 1 else "/dev/null"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: station2-centerFreq
    decim: '4'
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: station1-centerFreq
    decim: '4'
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: float
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1235'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 6,0,1,1
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: centerFreq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0_0, '0']
- [analog_wfm_rcv_0, '0', network_tcp_sink_0, '0']
- [analog_wfm_rcv_0_0, '0', blocks_wavfile_sink_0_0, '1']
- [analog_wfm_rcv_0_0, '0', network_tcp_sink_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
