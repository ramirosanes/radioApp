options:
  parameters:
    author: rami
    generate_options: qt_gui
    id: listenAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centerFreq
  id: variable_qtgui_range
  parameters:
    start: 570e3+offset
    step: 40e3
    stop: 1450e3+offset
    value: 1090e3+offset
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to recordings
      and adds timestamp
    value: rootdir+record_file_path+"_"+"Station1:"+str(int(centerFreq+station1-125e6))+"Hz_""Station2:"+str(int(centerFreq+station2-125e6))+"Hz_"+str(int(samp_rate))+"sps_"
  states: {}
- name: offset
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: rec_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 4,0,1,1
    initPressed: 'False'
    label: RECORD
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: green
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"/Documents/UBA/proyectoSDR/flowgraphs/recordings/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: station1
  id: variable_qtgui_range
  parameters:
    start: '-480e3'
    step: 40e3
    stop: 360e3
    value: '0'
  states: {}
- name: station2
  id: variable_qtgui_range
  parameters:
    start: '-480e3'
    step: 40e3
    stop: 360e3
    value: '0'
  states: {}
- name: taps_sca
  id: variable_low_pass_filter_taps
  parameters:
    beta: '6.76'
    cutoff_freq: '10000'
    gain: '2'
    samp_rate: '1920000'
    width: '40000'
    win: window.WIN_KAISER
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '625e-6'
    decay_rate: '10e-6'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '625e-6'
    decay_rate: '10e-6'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: 2e3
    audio_stop: 9.5e3
    chan_rate: '240000'
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: 2e3
    audio_stop: 9.5e3
    chan_rate: '240000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".wav" if rec_button == 1 else "/dev/null"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: station1
    decim: '2'
    samp_rate: samp_rate
    taps: taps_sca
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: station2
    decim: '2'
    samp_rate: samp_rate
    taps: taps_sca
    type: ccc
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: float
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1235'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '15'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '15'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: centerFreq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc2_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_am_demod_cf_0, '0', blocks_wavfile_sink_0_0, '0']
- [analog_am_demod_cf_0, '0', network_tcp_sink_0, '0']
- [analog_am_demod_cf_0_0, '0', blocks_wavfile_sink_0_0, '1']
- [analog_am_demod_cf_0_0, '0', network_tcp_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc2_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_am_demod_cf_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
