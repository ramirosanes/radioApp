options:
  parameters:
    author: pi
    generate_options: qt_gui
    id: doubleFMdemod_TCP
    output_language: python
    title: radioApp
  states: {}

blocks:
- name: centerFreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: '88300000'
    step: '200000'
    stop: '108900000'
    value: '94300000'
  states: {}
- name: double_station
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 4,0,1,1
    initPressed: 'False'
    label: double_station
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: green
    released: '0'
    type: int
    value: 'False'
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to recordings
      and adds timestamp
    value: rootdir+record_file_path+"_"+"Station1:"+str(int(centerFreq+station1))+"Hz_""Station2:"+str(int(centerFreq+station2))+"Hz_"+str(int(samp_rate))+"sps_"+str(rfGain)+"dB_"
  states: {}
- name: rec_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 5,0,1,1
    initPressed: 'False'
    label: RECORD
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: green
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"/Documents/UBA/proyectoSDR/flowgraphs/recordings/"'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF Gain (dB)
    start: '0'
    step: '0.1'
    stop: '30'
    value: '25'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: station1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-1200000'
    step: '200000'
    stop: '1200000'
    value: 400000 if double_station == 1 else 0
  states: {}
- name: station2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    start: '-1200000'
    step: '200000'
    stop: '1200000'
    value: '-400000 if double_station == 1 else 0'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '100000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '256000'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '256000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".wav" if rec_button == 1 else "/dev/null"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: station2
    decim: '10'
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: station1
    decim: '10'
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: float
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1235'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 6,0,1,1
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: centerFreq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0_0, '0']
- [analog_wfm_rcv_0, '0', network_tcp_sink_0, '0']
- [analog_wfm_rcv_0_0, '0', blocks_wavfile_sink_0_0, '1']
- [analog_wfm_rcv_0_0, '0', network_tcp_sink_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_wfm_rcv_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
